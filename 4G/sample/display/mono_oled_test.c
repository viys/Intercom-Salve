/*******************************************************************************
 ** Header Files
 ******************************************************************************/
#include "app_main.h"
#include "kingrtos.h"
#include "kingcstd.h"
#include "kingdisplay.h"

/*******************************************************************************
 ** MACROS
 ******************************************************************************/
#define LogPrintf(fmt, args...)    do { KING_SysLog("display: "fmt, ##args); } while(0)

#define MONO_OLED_REG_NUM       8
#define MONO_OLED_WIDTH         128
#define MONO_OLED_HEIGTH        64

#define MONO_BUF_SZ             (MONO_OLED_WIDTH * MONO_OLED_REG_NUM)

#define COLOR_BLACK     0X00
#define COLOR_WHITE     0XFF

/*******************************************************************************
 ** Type Definitions
 ******************************************************************************/

/*******************************************************************************
 ** Variables
 ******************************************************************************/
static char s_display_buff[MONO_BUF_SZ];

/*******************************************************************************
 ** External Function Declerations
 ******************************************************************************/

/*******************************************************************************
 ** Local Function Declerations
 ******************************************************************************/

/*******************************************************************************
 ** Functions
 ******************************************************************************/
void Lcd_Display(void)
{
    LCDDISPLAY_T rec;
    uint16 i = 0, j = 0;

    rec.x = 0;
    rec.y = 0;
    rec.width = MONO_OLED_WIDTH;
    rec.height = MONO_OLED_HEIGTH;

    // ȫ��
    for (i = 0; i < MONO_BUF_SZ; i++)
    {
        s_display_buff[i] = COLOR_WHITE;
    }
    KING_LcdDisplay(rec, (uint8 *)s_display_buff, 1, 0);
    KING_Sleep(3000);

    // ȫ��
    for (i = 0; i < MONO_BUF_SZ; i++)
    {
        s_display_buff[i] = COLOR_BLACK;
    }
    KING_LcdDisplay(rec, (uint8 *)s_display_buff, 1, 0);
    KING_Sleep(3000);

    // �׺ڰ׺����
    for (i = 0; i < MONO_OLED_REG_NUM; i++)
    {
        if (0 == i % 2)
        {
            for (j = 0; j < MONO_OLED_WIDTH; j++)
            {
                s_display_buff[i * MONO_OLED_WIDTH + j] = COLOR_WHITE;
            }
        }
        else
        {
            for (j = 0; j < MONO_OLED_WIDTH; j++)
            {
                s_display_buff[i * MONO_OLED_WIDTH + j] = COLOR_BLACK;
            }
        }
    }
    KING_LcdDisplay(rec, (uint8 *)s_display_buff, 1, 0);
    KING_Sleep(3000);

    // �ڰ׺ڰ����
    for (i = 0; i < MONO_OLED_REG_NUM; i++)
    {
        if (0 == i % 2)
        {
            for (j = 0; j < MONO_OLED_WIDTH; j++)
            {
                s_display_buff[i * MONO_OLED_WIDTH + j] = COLOR_BLACK;
            }
        }
        else
        {
            for (j = 0; j < MONO_OLED_WIDTH; j++)
            {
                s_display_buff[i * MONO_OLED_WIDTH + j] = COLOR_WHITE;
            }
        }
    }
    KING_LcdDisplay(rec, (uint8 *)s_display_buff, 1, 0);
    KING_Sleep(3000);
}


void mono_oled_Test(void)
{
    int ret = 0;
    LCDCONFIG_T config = {0};

    LogPrintf("mono_oled_Test...\r\n");
    
    ret = KING_LcdInit(0, &config);
    if (-1 == ret)
    {
        LogPrintf("KING_LcdInit fail: 0x%x\r\n", KING_GetLastErrCode());
        return;
    }
    
    ret = KING_LcdScreenOn(0);
    if (-1 == ret)
    {
        LogPrintf("KING_LcdScreenOn fail: 0x%x\r\n", KING_GetLastErrCode());
        return;
    }

    Lcd_Display();

    ret = KING_LcdScreenOff(0);
    if (-1 == ret)
    {
        LogPrintf("KING_LcdScreenOff fail: 0x%x\r\n", KING_GetLastErrCode());
        return;
    }

    ret = KING_LcdDeinit(0);
    if (-1 == ret)
    {
        LogPrintf("KING_LcdDeinit fail: 0x%x\r\n", KING_GetLastErrCode());
        return;
    }
}
